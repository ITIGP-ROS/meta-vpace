# this version uses the deprecated API way of subscribing to topics (so just disable the warning for now)
CXXFLAGS += "-Wno-error=deprecated-declarations"